<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\kdc.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>kdc</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>kdc</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>kdc</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>kdc</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


